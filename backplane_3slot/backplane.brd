# Repository worlickwerx/pi-cluster-two

File README.md:

## pi-cluster-two

This project is a redesign of
[pi-cluster-one](https://github.com/garlick/pi-cluster-one).

The planned scale of this design is 16 nodes, with a stretch goal of 64.

Its primary intended use is as a vehicle for learning about HPC cluster
internals, hardware design, and the open source ecosystem for hardware design.

The building blocks that comprise this cluster are:
* An 8-slot backplane with 96-pin DIN 41612 connectors
* A backplane supervisor (one per one or two 8-slot backplanes)
* An ATX (20-pin) power supply
* A raspberry pi compute node on a 100 x 160mm Eurocard
* A communications adapter, fitted on the compute node as a mezzanine board

### Networking

In addition to a regular gigabit ethernet network, the design of this
cluster supports:
* a CAN network for system management (on backplane)
* A wired-OR network for fast hardware barriers
* A binary tree for broadcast/reduction, consisting of three signle-lane,
  bidirectional LVDS links
* A 3D torus, consisting of six single-lane, bidirectional LVDS links
  (4 used for 2D torus, 2 for 1D torus)

The left-right torus dimension is hardwired on the backplane, in two
groups of four nodes.  Remaining torus and tree network links require
2-pair UTP cables connected to JST connectors on the backplane.

### System configurations

**compute nodes** | **backplanes** | **supervisors** | **tree cables** | **torus cables** | **notes**
:-- | :-- | :-- | :-- | :-- | :--
4   | 1   | 1   | 3   | 0   | 1D torus
16  | 2   | 1   | 15  | 16  | 2D torus (4x4)
64  | 8   | 4   | 63  | 128 | 3D torus (4x4x4)

### Compute node

A compute board carries a Raspberry Pi 4B with support circuitry including
a service processor for remote management and monitoring over CAN bus,
a 5x7 LED bargraph for status display, a CAN adapter for the Pi, and a
mezzanine slot for a communications adapter.

10 [version 2](hardware/pi-carrier/README.md) compute board PCBs were
were received and are being hand assembled/debugged.

A CM4 version is planned.

### Backplane

The backplane supports power distribution, geographic slot addressing,
a CAN mangement/monitoring bus, a wired-OR hardware barrier network,
a tree network for optimized MPI collectives, and a 2D torus mesh network.

Five [version 1](hardware/bus-8/README.md) backplanes have been ordered,
with PCBA assembly.

### Supervisor

The [version 1](hardware/supervisor/README.md) supervisor design is being
finalized.

### Communications adapter

Not yet designed, but availability of a PCIe lane on the CM4 makes this
somewhat more interesting than before.

### Software status Feb 2021

STM32 firmware on the compute board version 1 and 2 is fully functional.
The firmware "personality" for the supervisor board is not yet complete
(it will use the same firmware image).

Tools on linux for snooping the CAN bus with message decoding, pinging
over CAN, reading slot address over I2C, etc. are functional.

Integration with [powerman](http://github.com/chaos/powerman) and
[conman](http://github.com/dun/conman) for remote power and console
management of a single crate is functional.

The basics of the [CAN protocol](doc/CAN.md) are documented.

### origin and license

#### software

SPDX-License-Identifier: GPL-3.0-or-later

#### hardware

SPDX-License-Identifier: CERN-OHL-1.2

#### credits

This project includes parts of:
* FreeRTOS (MIT license)
* libopencm3 (LGPLv3+)
* project templates from the book _Beginning STM32_ by Warren Gay (LGPLv3+)

The CAN control bus and LED matrix were influenced by similar features
of the [Meiko CS/2](https://github.com/garlick/meiko-cs2), a ground breaking
supercomputer of the 1990's.

The communcations design is patterned after
[Blue Gene/L](https://en.wikipedia.org/wiki/IBM_Blue_Gene), circa 2005.

## EAGLE design backplane_3slot/backplane.brd

Parts:
X1, X2, X3: FABC48B2

Connections:
+5V: X1.A1, X1.B1, X1.C1, X2.A1, X2.B1, X2.C1, X3.A1, X3.B1, X3.C1
GND: X1.A11, X1.A16, X1.B11, X1.B13, X1.B16, X1.C11, X1.C12, X1.C13, X1.C16, X2.A11, X2.A16, X2.B11, X2.B12, X2.B13, X2.B16, X2.C11, X2.C12, X2.C13, X2.C16, X3.A11, X3.A16, X3.B11, X3.B12, X3.B13, X3.B16, X3.C11, X3.C13, X3.C16
LCAN-H: X1.C5, X2.C5, X3.C5
LCAN-L: X1.C4, X2.C4, X3.C4
MOD-A0: X1.B14, X2.B14, X3.B14
MOD-A1: X1.C14, X2.C14, X3.C14
MOD-A2: X1.B15, X2.B15, X3.B15
MOD-A3: X1.C15, X2.C15, X3.C15

Board: 2 copper layers, 85.3 x 58.4 mm, 3 parts (0 on the bottom side), 8 nets.

## EAGLE design backplane_1slot/backplane.brd

Parts:
S1: DS04; DS-04
X1: FABC48B2
X2, X3: 2510-; PAK100/2500-10

Connections:
+5V: X1.A1, X1.B1, X1.C1, X2.1, X2.2
CLK-HSE: X1.C10
CLK-LSE: X1.C9
GND: S1.5, S1.6, S1.7, S1.8, X1.A16, X1.B16, X1.C16, X2.3, X2.4, X3.3, X3.4
LCAN-H: X1.C5, X2.9
LCAN-L: X1.C4, X2.10
MOD-A0: X1.B14, X2.5
MOD-A1: X1.C14, X2.6
MOD-A2: X1.B15, X2.7
MOD-A3: X1.C15, X2.8
NODE-A0: S1.1, X1.B12
NODE-A1: S1.2, X1.C12
NODE-A2: S1.3, X1.B13
NODE-A3: S1.4, X1.C13
SWCLK: X1.C7, X3.6
SWDIO: X1.C6, X3.2
SWO: X1.C8, X3.9, X3.10

Board: 2 copper layers, 85.3 x 66.3 mm, 4 parts (0 on the bottom side), 15 nets.

## EAGLE design hardware_v2/daughter.brd

Parts:
C1, C2, C3, C5, C6, C7: 100nF; C1206
C4: 1uF; C1206
K1: PIN20X2; PIN_20X2
LED1, LED2, LED3, LED4: LEDCHIP-LED0805; CHIP-LED0805
R1, R2: 3K9; M1206
R3, R4, R5, R6, R7, R8: 10K; M1206
R9: 330; M1206
R10, R11, R12: 220; M1206
U1: STM32F103_TQFP48_7X7; LQFP48_7X7
U2: MCP2551-I/SN; SOIC127P600X175-8N
U3: LM1117IMPX-3.3; SOT223
U4: TPS27081A; SOT95P280X145-6N
U$2: MF-SMDF050
X1: MABC48B2

Connections:
+3V3: K1.1, K1.17, R1.2, R2.2
+5V: C5.1, K1.2, K1.4, R9.2, U4.2 (VOUT1), U4.3 (VOUT2)
ALIVE: R12.2, U1.25 (PB12)
BUS5V: C1.1, C2.1, C4.1, R6.2, U2.3 (VDD), U3.3 (IN), U4.4 (VIN), U$2.2
CONS-RX: K1.10, U1.30 (PA9)
CONS-TX: K1.8, U1.31 (PA10)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, K1.6, K1.14, K1.20, K1.25, K1.30, K1.34, K1.39, LED1.C, LED2.C, LED3.C, LED4.C, R3.1, R5.1, R7.2, R8.1, U1.8 (VSSA), U1.23 (VSS_1), U1.35 (VSS_2), U1.47 (VSS_3), U2.2 (VSS), U3.1 (GND), U4.1 (R2), X1.A16, X1.B16, X1.C16
ID-SC: K1.28, R1.1, U1.21 (PB10)
ID-SD: K1.27, R2.1, U1.22 (PB11)
IDENTIFY: R11.2, U1.46 (PB9)
LCAN-ACT: R10.2, U1.41 (PB5)
LCAN-H: U2.7 (CANH), X1.C5
LCAN-L: U2.6 (CANL), X1.C4
LCAN-RX: U1.32 (PA11), U2.4 (RXD)
LCAN-TX: U1.33 (PA12), U2.1 (TXD)
MOD-A0: U1.14 (PA4), X1.B14
MOD-A1: U1.15 (PA5), X1.C14
MOD-A2: U1.16 (PA6), X1.B15
MOD-A3: U1.17 (PA7), X1.C15
unnamed: R6.1, U4.6 (R1/C1)
unnamed: R7.1, U1.44 (BOOT0)
unnamed: U$2.1, X1.A1, X1.B1, X1.C1
unnamed: LED4.A, R12.1
unnamed: R3.2, U1.20 (PB2)
unnamed: LED3.A, R11.1
unnamed: LED2.A, R10.1
unnamed: LED1.A, R9.1
unnamed: R8.2, U2.8 (RS)
NODE-A0: U1.10 (PA0-WKUP), X1.B12
NODE-A1: U1.11 (PA1), X1.C12
NODE-A2: U1.12 (PA2), X1.B13
NODE-A3: U1.13 (PA3), X1.C13
NRST: R4.1, U1.7 (NRST)
OSC-HSE: U1.5 (PD0-OSC_IN), X1.C10
OSC-LSE: U1.3 (PC14-OSC32_IN), X1.C9
PWR-ON: R5.2, U1.26 (PB13), U4.5 (ON/OFF)
PWR-SENSE: K1.37, U1.28 (PB15)
PWR-SHUTDOWN: K1.38, U1.27 (PB14)
SCL: K1.5, U1.42 (PB6)
SDA: K1.3, U1.43 (PB7)
STBY3V3: C3.1, C6.1, C7.1, R4.2, U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD_1), U1.36 (VDD_2), U1.48 (VDD_3), U3.2 (OUT), U3.TAB (OUT1)
SWCLK: U1.37 (PA14), X1.C7
SWDIO: U1.34 (PA13), X1.C6
SWO: U1.39 (PB3), X1.C8

Notes on the sheet:
Raspberry Pi
Compute Board V2
L-CAN transceiver
2.5A PTC
STM32F103C8T6
RED
GRN
YEL
BLU

Board: 2 copper layers, 78.5 x 59.3 mm, 30 parts (1 on the bottom side), 44 nets.

## Commit log (part)

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2020-12-19 firmware/canbus: enable auto bus off management
    Problem: Auto bus off can disconnect us from bus if error count
    reaches a threshold. Since ABOM is off, there is no recovery.
    Enable ABOM.
2020-12-23 firmware/i2c: enable matrix update
    Display the 'F' (0x46) character on the LED matrix:
    i2cset 1 0xe30 13 0x46
    Set all LEDs in the matrix
    i2cset 1 0x30 12 0x7f 0x7f 0x7f 0x7f 0x7f i
    Clear all LEDs in the matrix
    i2cset 1 0x30 12 0 0 0 0 0 i
2020-12-27 cm4-compute: begin schematic for GPIO portion
2020-12-28 cm4-compute: drop SD card symbol from schematic
2020-12-31 cm4-compute: add M.2 to board
2021-01-11 firmware: disable serial while unconnected
    Problem: when user connects to console, they see
    a buffer worth of backlog.
    This seems wrong. Disable serial capture when there
    is no connection.
2021-01-16 firmware: fix whitespsace in FreeRTOSConfig.h
2021-01-16 firmware: refactor canbus
    Problem: canbus.c has grown too complicated.
    Split the canmsg_v1 service implementations to canservice.c.
2021-01-21 drivers: add CAN device tree overlay
    Import mcp2515-can0-overlay.dts from raspberry pi linux-5.10
    source tree and modify for SPI bus 1, device 0.
    Enable with the following in config.txt:
    dtparam=spi=on
    dtoverlay=spi1-1cs
    dtoverlay=mcp2515-can2,interrupt=12
2021-01-23 libbramble/canlinux: clear xmsgidf on SFF frame receipt
    Problem: xmsgidf is set on both size IDs.
    Fix logic.
2021-01-23 libbramble: add canobj
2021-01-24 bramble: allow BRAMBLE_SLOT environment var
    Problem: bramble can utils won't work on a board that doesn't
    have the STM32 processor connected with I2C, because it cannot
    determine its address.
    If BRAMBLE_SLOT is set in the environment, override the I2C.
2021-01-24 bramble/console: ignore non-console messages
2021-02-02 firmware: convert to v2 CAN protocol
2021-02-03 README.md: update firmware status
2021-02-07 bramble: install CAN filters
    Problem: the raw CAN interface is configured without filters,
    causing unnecessary wake-ups for CAN processes such as the power
    and console helpers.
    Add an argument to can_open() to allow the local address to be
    specified, and then install filters for that destination address
    and the broadcast address.
2021-02-07 firmware/console: allow multiple DAT per ACK
    Problem: the serial console buffer can be overrun due to
    lock-step DAT/ACK protocol.
    While the serial buffer has data, send up to 16 sequenced DAT
    messages back to back before requiring an ACK by setting eot=1.
    This implementation is still not optimal since transmission
    pauses after the 16th DAT is sent, waiting for the ACK, rather
2021-04-18 firmware/blink: change RTOS LED duty cycle
    Problem: green light is spending too much time on.
    It's annoying.
    Instead of toggling the LED every 500ms, turn it on for
    1ms and then off for 2000ms.
2022-03-05 firmware: add some notes on building the firwmare
    Problem: I have to keep looking stuff up to remember how to
    build the firmware.
    Add some notes in a markdown file.
2022-03-19 bramble: add systemd unit file
    Problem: bramble usage-bargraph has to be started manually
    with a pdsh.
    Add a systemd unit file that runs bramble usage-bargraph
    when the system boots.
    Add some helpful m4 macros to:
    - help autotools grok systemd
2022-03-25 firmware: keep wall clock time
    Problem: we need to track the wall clock for RTC emulation.
    The STM32 RTC hardware can keep time across a power cycle IFF:
    - VBAT is powered
    - LSE clock source is used
    however pi carrier v2 does not wire VBAT, nor drive the OSC32 XTAL
    inputs used for the LSE clock. The LSE is the only clock source
2022-06-15 bramble: add shutdown subcommand
    Problem: there is no way to exercise CAN SHUTDOWN object.
    Add 'bramble shutdown SLOT' which:
    1. sets the SHUTDOWN object to 1, which triggers the gpio-shutdown
    overlay on the pi, causing systemd to receive a poweroff keypress
    2. polls the SHUTDOWN object periodically until a 1 is read, which
    indicates that the OS has shut down.
2022-06-19 pi-carrier: convert board to kicad 6
    Problem: pi-carrier was created under kicad 5 but 6 is now the current
    version.
    Save eurocard.kicad_pcb under kicad 6.
2022-06-25 firmware: drop power flip flop
    Problem: the power flip flop is no longer needed, since we
    can tell the difference between a power on reset and other types
    of reset by testing (RCC_CSR & PORRSTF).
    Change pi power control code to use that technique instead of the
    flip flop, which may be removed from future designs.
2022-06-26 pi-carrier: change holes for pi mounting hardware
    Problem: mounting holes for pi bracket are not currently used.
    Drop one mounting hole.
    Add two stablization holes for a new bracket (TBD).
2022-06-26 pi-carrier: fix JST schematic symbol
    Problem: Schematic symbol for 3 pin JST connectors do not include
    mounting terminals.
    Change to symbol with mounting terminals and tie to ground plane.
2022-06-26 pi-carrier: drop header for comms pins
    Problem: header for comms pins is unused.
    Drop header.
2022-06-27 pi-carrier: drop disconnected flag on unused power
    Problem: ERC fails on unused bus power pins because they are
    marked disconnected, but are ganged in the symbol.
    Drop disconected flag.
2022-06-27 pi-carrier: fix U8 footprint
    Problem: U8 was assigned a footprint from an external digikey
    library, then we assigned the wrong native one on converting
    to kicad 6.
    Select the correct native footprint.
2022-06-27 pi-carrier: add track width to pull down
2022-06-29 pi-carrier: change 32.768khz xtal footprint
    Problem: rtc xtal is too big
    Go with Abracon ABS07-32.768KHZ-T (in stock at digikey).
2022-06-29 pi-carrier: add more test points
    Problem: some key probing points are still inaccessible.
    Expand test points. Change "value" field to match function.
2022-07-04 pi-carrier: fix footprint etc
2022-07-04 footprints: fix right angle matrix socket
    Problem: there was a garbage 3d reference in footprint attrs.
    Remove garbage refs
2022-07-07 pi-carrier: update 3d image
2022-07-30 hardware: add pi front panel
    Problem: pi carrier 3d printed PLA front panel is not sufficiently
    rigid and does not support an ejector lever.
    Have a go at converting the kludge card PCB front panel for use
    with the pi-carrier. The pi holes are in a separate footprint,
    since it was easier to translate the FreeCAD parameters to a zero
    origin footprint.
2023-06-16 firmware: tidy up power initialization and document
    Problem: power control initialization is sparsely documented.
    Add some inline docs and reorganize the code for readability.
2023-12-29 doc: add copyright header to sources
    Problem: copyright is missing from source code.
    Add a boiler plate copyright header to the original *.[ch].
2023-12-30 build: add bramble-fw-update script
    Problem: a firmware update currently requires the source
    tree to be present.
    Install a script for updating the firwmare from /lib/bramble.fw.
    Also: add a 'make flash' target in the firmware directory that
    calls this script.
2024-01-08 firmware: clear address from matrix after 2s
    Problem: when a pi is off for a long time, leaving the bus
    address up there just wastes power and looks dumb.
    Clear it after 2s.
2024-01-15 pi-carrier: fix ERC errors
    Problem: several bus power pins were labeled but unconnected.
    Drop labels and wires on those pins and mark 'X' (NC).
2024-01-15 pi-carrier: update to kicad 7.0.9
    Problem: pi-carrier was developed with kicad 6.
    Open the project in kicad-7.0.9~ubuntu22.04.1 and save it.
2024-01-15 pi-carrier: fix board short
    Problem: a DRC error calls out a clearance violation at the J2
    debug connector.
    Relocate 3V3 power trace to avoid JST footprint.
    Fix resulting ground plane split.
2024-01-16 pi4_panel_4hp: rename from pi_carrier_panel_4hp
    Problem: panel project name is too long
    Shorten it.
2024-02-17 Revert "firmware: add pi 5 power control support"
    Problem: the problem of the pi 5's power button has been solved
    with the addition of a load switch on the adapter board, so
    the clunky firmware changes are no longer needed.
    Moreover, the load switch works with the older pi's.
    This reverts commit a02747ab8d2630805885d843114568900f7e5cc8.
2024-02-17 pi-carrier: fix console label
    Problem: console label did not show up on silk
    Same problem as with the test points in the last commit, and same fix.
    Add a separate descriptive silk label.
2024-02-18 pi-carrier: add sdcard pic on back of board
    Problem: earlier designs have placed obstacles in the way of
    inserting the sdcard.
    Add an sdcard image to the silk layer to hopefully prevent that sort
    of error in the future.
2024-02-20 pi-carrier: reroute pi GPIO lines
    Problem: pi GPIO traces are inefficiently routed and are crossing
    the area on the front fo the board where M.2 traces will go.
    Reroute.
2024-02-20 pi-carrier: update M.2 power circuit
    Problem: oops, TI buck converter is obsolete.
    Use the pin-compatible replacement, TPS563203.
    Adjust recommended component values for 3V3 and add some
    more passives per the new spec sheet.
2024-02-26 pi-carrier: fix efuse powerpad signal type
    Problem: the efuse has a "powerpad" on the bottom that is
    labeled as a bidirectional pin but should be grounded.
    Fix the symbol to make that a power pin.
    Also drop the symbol's implicit connection to a nonexistent footprint.
2024-02-26 pi-carrier: fix efuse schematic formatting
    Problem: a subscript in notes is not formatted correctly.
    Fix formatting.
2024-02-26 pi-carrier: address pcbway concnern
    Problem: pcbway enginner says differential clock signal is
    too close the the board edge and must be >= 0.15mm.
    Move pcie clock away from board edge.
2024-03-18 build: add hardware configure logic
    Problem: kicad-cli in version 8 allows ERC/DRC and CAM generation
    to be run programmatically, but our build system does not take
    advantage of that.
    Add configure logic in the hardare subdirectory that looks for
    an appropriately recent version of kicad.
    If --with-kicad is specified, not finding one is an error.
2024-03-18 pi5_adapter: fix board DRC errors
    Problem: schematic fails DRC
    Add lib.pretty library (containing 5 pin SIP connector).
    Update all symbols from library.
    Remove stray board edge line.
2024-03-19 pi5_adapter: add fp-lib-table, sym-lib-table
    Problem: fp-lib-table and sym-lib-table should have been checked
    into git.
    Add them.
2024-04-14 pi-carrier: flip M.2 slot upside-down and reroute
    Problem: the differential traces for the M.2 slot are longer
    than they need to be, and impedance needs to be recalculated
    for the 4-layer board.
    Use JLPCB's recommended trace width of 6.1200 mils (0.1555 mm)
    and spacing of 8.0000 mils (0.2032 mm) for 90 ohms using their
    default 4-layer stackup.
2024-04-20 pi-carrier: refine pcie diff pair routing
    Problem: top copper clearance for pcie diff pairs is too small.
    Give each pair 5 times the trace width (0.7925 mm) on each side.
    Also: add F.Fab notes about desired impedance.
2024-04-21 pi-carrier: improve clearance on diffpair tracks
    Problem: there is not enough clearance between pcie signals
    and the edge of the board.
    Reroute traces and adjust keepouts to ensure a minimum of 0.7915mm
    between traces and top ground plane or board edge. Shrink keepouts
    in other places to reduce the clearance to around that.
2024-04-23 pi5_adapter: update symbols
    Problem: kicad 8.0.1 is throwing ERC errors about out of date
    symbols.
    Update symbols.
2024-04-27 pi-carrier: update 3d view
