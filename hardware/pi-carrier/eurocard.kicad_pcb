# Repository worlickwerx/pi-cluster-two

File README.md:

## pi-cluster-two

This project is a redesign of
[pi-cluster-one](https://github.com/garlick/pi-cluster-one).

The planned scale of this design is 16 nodes, with a stretch goal of 64.

Its primary intended use is as a vehicle for learning about HPC cluster
internals, hardware design, and the open source ecosystem for hardware design.

The building blocks that comprise this cluster are:
* An 8-slot backplane with 96-pin DIN 41612 connectors
* A backplane supervisor (one per one or two 8-slot backplanes)
* An ATX (20-pin) power supply
* A raspberry pi compute node on a 100 x 160mm Eurocard
* A communications adapter, fitted on the compute node as a mezzanine board

### Networking

In addition to a regular gigabit ethernet network, the design of this
cluster supports:
* a CAN network for system management (on backplane)
* A wired-OR network for fast hardware barriers
* A binary tree for broadcast/reduction, consisting of three signle-lane,
  bidirectional LVDS links
* A 3D torus, consisting of six single-lane, bidirectional LVDS links
  (4 used for 2D torus, 2 for 1D torus)

The left-right torus dimension is hardwired on the backplane, in two
groups of four nodes.  Remaining torus and tree network links require
2-pair UTP cables connected to JST connectors on the backplane.

### System configurations

**compute nodes** | **backplanes** | **supervisors** | **tree cables** | **torus cables** | **notes**
:-- | :-- | :-- | :-- | :-- | :--
4   | 1   | 1   | 3   | 0   | 1D torus
16  | 2   | 1   | 15  | 16  | 2D torus (4x4)
64  | 8   | 4   | 63  | 128 | 3D torus (4x4x4)

### Compute node

A compute board carries a Raspberry Pi 4B with support circuitry including
a service processor for remote management and monitoring over CAN bus,
a 5x7 LED bargraph for status display, a CAN adapter for the Pi, and a
mezzanine slot for a communications adapter.

10 [version 2](hardware/pi-carrier/README.md) compute board PCBs were
were received and are being hand assembled/debugged.

A CM4 version is planned.

### Backplane

The backplane supports power distribution, geographic slot addressing,
a CAN mangement/monitoring bus, a wired-OR hardware barrier network,
a tree network for optimized MPI collectives, and a 2D torus mesh network.

Five [version 1](hardware/bus-8/README.md) backplanes have been ordered,
with PCBA assembly.

### Supervisor

The [version 1](hardware/supervisor/README.md) supervisor design is being
finalized.

### Communications adapter

Not yet designed, but availability of a PCIe lane on the CM4 makes this
somewhat more interesting than before.

### Software status Feb 2021

STM32 firmware on the compute board version 1 and 2 is fully functional.
The firmware "personality" for the supervisor board is not yet complete
(it will use the same firmware image).

Tools on linux for snooping the CAN bus with message decoding, pinging
over CAN, reading slot address over I2C, etc. are functional.

Integration with [powerman](http://github.com/chaos/powerman) and
[conman](http://github.com/dun/conman) for remote power and console
management of a single crate is functional.

The basics of the [CAN protocol](doc/CAN.md) are documented.

### origin and license

#### software

SPDX-License-Identifier: GPL-3.0-or-later

#### hardware

SPDX-License-Identifier: CERN-OHL-1.2

#### credits

This project includes parts of:
* FreeRTOS (MIT license)
* libopencm3 (LGPLv3+)
* project templates from the book _Beginning STM32_ by Warren Gay (LGPLv3+)

The CAN control bus and LED matrix were influenced by similar features
of the [Meiko CS/2](https://github.com/garlick/meiko-cs2), a ground breaking
supercomputer of the 1990's.

The communcations design is patterned after
[Blue Gene/L](https://en.wikipedia.org/wiki/IBM_Blue_Gene), circa 2005.

## KiCad design hardware/pi-carrier/eurocard.kicad_pcb

File hardware/pi-carrier/README.md:

## pi-carrier

See also:
* [schematic v3](schematic_v3.pdf)
* [schematic v2](schematic_v2.pdf)
* [schematic v1](schematic_v1.pdf)

Parts:
C2: 1uF; C_0603_1608Metric; MPN CL21A106KOFNNNE
C4: 1uF; C_0603_1608Metric; MPN CL21A226MOCLRNC
C6, C13: 8pf; C_0603_1608Metric; MPN C0805C104K4RACTU
C9, C10, C12, C14, C15, C16, C20: 100nF 16V; C_0603_1608Metric; MPN C0805C104K4RACTU
D1: BAT54CW; SOT-323_SC-70
D3: LED_GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; MPN APT2012SGC
J1: DIN41612_C96_male_ra_molliebus; DIN41612_C_3x32_Male_Horizontal_THT; MPN 09031966921
J5: Conn_02x20_raspberry_pi4B; Rasp_pi4_mounted; MPN PRPC020DAAN-RC
J9: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD
J10: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
JP7: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R1, R5: 10K; R_0603_1608Metric
R12, R13: 4.7K; R_0603_1608Metric
R14, R16, R19: 100K; R_0603_1608Metric
R15: 1K; R_0603_1608Metric
TP18, TP19, TP20, TP21, TP22: TestPoint; TestPoint_Pad_1.0x1.0mm
U1: 74LVC1G07; SOT-753; MPN SN74LVC1G07DBVR; Digi-Key_PN 296-8485-1-ND
U2: TCAN332DR; SOIC-8_3.9x4.9mm_P1.27mm; MPN TCAN332DR
U6: STM32F103C8T6; LQFP-48_7x7mm_P0.5mm; MPN STM32F103C8T6
U14: TLV75733PDBV; SOT-23-5
X2: ASE-8.000MHz-LC; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN ASE-8.000MHz-LC
Y1: ABS07-32.768KHZ-6-T; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3V3: C9.1, C10.1, C12.1, C15.1, C16.1, D1.2, D3.2 (A), J9.1, JP7.2 (B), R1.1, R5.1, R12.1, R13.1, U1.5 (VCC), U2.3 (VCC), U6.9 (VDDA), U6.24 (VDD), U6.36 (VDD), U6.48 (VDD), X2.4 (Vdd)
+BATT: C20.2, D1.3, U6.1 (VBAT)
/BARRIER_EN: U6.38 (PA15)
/BARRIER_IN: J5.31 (GCLK2/GPIO6)
/BARRIER_OUT: J5.29 (GCLK1/GPIO5)
/BOOT1: R16.2, U6.20 (PB2)
/BUS5V: J1.a1 (BUS5V), J1.a32 (BUS5V), J1.b1 (BUS5V), J1.b32 (BUS5V), J1.c1 (BUS5V), J1.c32 (BUS5V); also elsewhere on the board
/BUS_BATT+: D1.1, J1.a23 (TROUT_TX+)
/BUTTON1: J1.a25 (TROUT_RX+), U6.13 (PA3)
/CAN+: J1.a5 (CAN+), U2.7 (CANH); also elsewhere on the board
/CAN-: J1.a4 (CAN-), U2.6 (CANL); also elsewhere on the board
/CANRX: U2.4 (RXD), U6.45 (PB8)
/CANTX: U2.1 (TXD), U6.46 (PB9)
/CAN_MISO: J5.35 (GPIO19/MISO1); also elsewhere on the board
/CAN_MOSI: J5.38 (GPIO20/MOSI1); also elsewhere on the board
/CAN_SCLK: J5.40 (GPIO21/SCLK1); also elsewhere on the board
/CONSOLE_RX: J10.7, U6.31 (PA10)
/CONSOLE_TX: J10.9, U6.30 (PA9)
/GA0: J1.a6 (GA0), U6.10 (PA0)
/GA1: J1.a7 (GA1), U6.11 (PA1)
/GA2: J1.a8 (GA2), U6.43 (PB7)
/GA3: J1.a9 (GA3), U6.42 (PB6)
/GA4: J1.a10 (GA4), U6.41 (PB5)
/GLOBAL_EN: J10.3, U6.27 (PB14)
/MOSI: U6.28 (PB15); also elsewhere on the board
/NSS: R5.2, U6.25 (PB12); also elsewhere on the board
/OR_INA: J1.a15 (OR_INA)
/OR_INB: J1.a16 (OR_INB)
/OR_OUT: J1.a17 (OR_OUT)
/OSC_IN: U6.5 (PD0), X2.3 (OUT)
/PC14: C6.2, U6.3 (PC14), Y1.2
/PC15: C13.2, U6.4 (PC15), Y1.1
/PI_3V3: J5.1 (3V3), J5.17 (3V3); also elsewhere on the board
/PI_HALT: J5.13 (GPIO27), U6.14 (PA4)
/RUN_PG: J10.1, U6.29 (PA8)
/SAFE_5V: C2.1, J5.2 (5V), J5.4 (5V), R19.2, U14.1 (IN); also elsewhere on the board
/SCK: U6.26 (PB13); also elsewhere on the board
/SCL: J5.5 (SCL/GPIO3), R13.2, U6.21 (PB10)
/SDA: J5.3 (SDA/GPIO2), R12.2, U6.22 (PB11)
/SWCLK: J5.33 (PWM1/GPIO13), J9.4, U6.37 (PA14)
/SWDIO: J5.36 (GPIO16), J9.2, U6.34 (PA13)
/SWO: J9.6, U6.39 (PB3)
/~CAN_CS: J5.12 (GPIO18/PWM0); also elsewhere on the board
/~CAN_INT: J5.32 (PWM0/GPIO12); also elsewhere on the board
/~PI_HALTED: J5.37 (GPIO26), U6.15 (PA5)
/~RESET: J1.a14 (~RESET), U1.2 (A)
/~RST: C14.1, J9.10, R1.2, U1.4 (Y), U6.7 (NRST)
GND: C2.2, C4.2, C6.1, C9.2, C10.2, C12.2, C13.1, C14.2, C15.2, C16.2, C20.1, J1.a2 (GND), J1.a12 (GND), J1.a22 (GND), J1.a24 (TROUT_TX-), J1.a26 (TROUT_RX-), J1.a31 (GND), J1.b2 (GND), J1.b12 (GND), J1.b22 (GND), J1.b31 (GND), J1.c2 (GND), J1.c12 (GND), J1.c22 (GND), J1.c31 (GND), J5.6 (GND), J5.9 (GND), J5.14 (GND), J5.20 (GND), J5.25 (GND), J5.30 (GND), J5.34 (GND), J5.39 (GND), J9.3, J9.5, J9.9, J10.5, R14.2, R16.1, U1.3 (GND), U2.2 (GND), U6.8 (VSSA), U6.23 (VSS), U6.35 (VSS), U6.47 (VSS), U14.2 (GND), X2.2 (GND); also elsewhere on the board
unnamed: D3.1 (K), R15.2
unnamed: C4.1, JP7.1 (A), U14.5 (OUT)
unnamed: R14.1, U6.44 (BOOT0)
unnamed: TP19.1, U6.16 (PA6)
unnamed: TP20.1, U6.17 (PA7)
unnamed: TP21.1, U6.32 (PA11)
unnamed: TP22.1, U6.33 (PA12)
unnamed: TP18.1, U6.40 (PB4)
unnamed: R15.1, U6.2 (PC13)
unnamed: R19.1, U14.3 (EN)

Notes on the sheet:
Raspberry pi
Reset
key

Parts:
C17, C18, C19: 100nF 16V; C_0603_1608Metric; MPN C0805C104K4RACTU
U11: TCAN332DR; SOIC-8_3.9x4.9mm_P1.27mm; MPN TCAN332DR
U12: MCP2518FD; SOIC-14_3.9x8.7mm_P1.27mm
X1: ASE-40.000MHz-LC; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN ASE-16.000MHz-LC

Connections:
/CAN+: U11.7 (CANH); also elsewhere on the board
/CAN-: U11.6 (CANL); also elsewhere on the board
/CAN_MISO: U12.12 (SDO); also elsewhere on the board
/CAN_MOSI: U12.11 (SDI); also elsewhere on the board
/CAN_SCLK: U12.10 (SCK); also elsewhere on the board
/PI_3V3: C17.1, C18.1, C19.1, U11.3 (VCC), U12.14 (VDD), X1.4 (Vdd); also elsewhere on the board
/~CAN_CS: U12.13 (nCS); also elsewhere on the board
/~CAN_INT: U12.4 (~INT); also elsewhere on the board
GND: C17.2, C18.2, C19.2, U11.2 (GND), U12.7 (VSS), X1.2 (GND); also elsewhere on the board
unnamed: U11.4 (RXD), U12.2 (RXCAN)
unnamed: U11.1 (TXD), U12.1 (TXCAN)
unnamed: U12.6 (OSC1), X1.3 (OUT)

Parts:
C28: 47nF; C_0603_1608Metric
D5: green; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6: red; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10: 49.9K; R_0603_1608Metric
R11, R17: 4.7K; R_0603_1608Metric
U13: TPS2421-1DDAR; VREG_LM5017MR_NOPB

Connections:
/BUS5V: R11.2, R17.2, U13.3 (VIN); also elsewhere on the board
/SAFE_5V: U13.7 (VOUT); also elsewhere on the board
GND: C28.1, R10.1, U13.2 (~EN), U13.4 (GND), U13.9 (EP); also elsewhere on the board
unnamed: D5.2 (A), R17.1
unnamed: D5.1 (K), U13.8 (~PG)
unnamed: D6.2 (A), R11.1
unnamed: D6.1 (K), U13.1 (~FLT)
unnamed: C28.2, U13.6 (CT)
unnamed: R10.2, U13.5 (ISET)

Notes on the sheet:
Notes: R10 determines current limit: I_{SET} = fault current (fault timer started) I_{LIM} = 1.5 * I_{SET} R_{RSET} = 200KΩ / I_{SET} (recommended range of 49.9K to 200K) For maximum current within recommendations, R_{RSET} = 49.9K. I_{SET} = 200K / 49.9K = 4.0A I_{LIM} = 1.5 * 4.0A = 6.0A C28 dete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

Parts:
C21, C22: 10uF; C_0603_1608Metric
C23, C27: 100nF; C_0603_1608Metric
C24, C25: 22uF; C_0603_1608Metric
C26: 10pF; C_0603_1608Metric
D4, D7: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J4: Bus_M.2_Socket_M; Conn_TE-M.2-0.5-67P-doublesided_TypeM
J7: Conn_01x16_MountingPin; CONN_F31W-1A7H1-11016_AMP
L1: 4.7uH; L_7.3x7.3_H4.5
R2: 135K; R_0603_1608Metric
R3: 30K; R_0603_1608Metric
R4: 100K; R_0603_1608Metric
R6, R18: 220; R_0603_1608Metric
R7: 6.8K; R_0603_1608Metric
R8: 3.6K; R_0603_1608Metric
U7: TPS563203; SOT-563

Connections:
/M.2 Storage/ACTIVITY_LED: D4.1 (K), J4.10 (DAS/~DSS/~LED1)
/M.2 Storage/M2_3V3: C24.1, C25.1, C26.2, J4.2 (3.3V), J4.4 (3.3V), J4.12 (3.3V), J4.14 (3.3V), J4.16 (3.3V), J4.18 (3.3V), J4.70 (3.3V), J4.72 (3.3V), J4.74 (3.3V), L1.2, R2.1, R6.2
/M.2 Storage/PCIE_CLKREQ_N: J4.52 (~CLKREQ), J7.15
/M.2 Storage/PCIE_CLK_N: J4.53 (REFCLKn), J7.5
/M.2 Storage/PCIE_CLK_P: J4.55 (REFCLKp), J7.4
/M.2 Storage/PCIE_DET_WAKE: J7.14, R7.1, R8.2
/M.2 Storage/PCIE_PWR_EN: J7.13, R4.1, R18.2, U7.5 (EN)
/M.2 Storage/PCIE_RST_B: J4.50 (~PERST), J7.16
/M.2 Storage/PCIE_RX_N: J4.43 (PERp0/SATA-B-), J7.8
/M.2 Storage/PCIE_RX_P: J4.41 (PERn0/SATA-B+), J7.7
/M.2 Storage/PCIE_TX_N: J4.49 (PETp0/SATA-A+), J7.11
/M.2 Storage/PCIE_TX_P: J4.47 (PETn0/SATA-A-), J7.10
/M.2 Storage/PI_5V: J7.1, J7.2, R8.1
/SAFE_5V: C21.1, C22.1, C27.1, U7.1 (VIN); also elsewhere on the board
GND: C21.2, C22.2, C24.2, C25.2, C27.2, D7.1 (K), J4.1 (GND), J4.3 (GND), J4.9 (GND), J4.15 (GND), J4.21 (GND), J4.27 (GND), J4.33 (GND), J4.39 (GND), J4.45 (GND), J4.51 (GND), J4.57 (GND), J4.71 (GND), J4.73 (GND), J4.75 (GND), J4.MP (GND), J7.3, J7.6, J7.9, J7.12, J7.MP (MountPin), R3.2, R4.2, R7.2, U7.3 (GND); also elsewhere on the board
unnamed: D4.2 (A), R6.1
unnamed: D7.2 (A), R18.1
unnamed: C23.1, U7.4 (BST)
unnamed: C26.1, R2.2, R3.1, U7.6 (FB)
unnamed: C23.2, L1.1, U7.2 (SW)

Notes on the sheet:
Differential routing notes: Goal: 90R +/-10% differential impedance[1] Stackup: JLC04161H-3313 (low cost from JLCPCB) JLCPCB calculator (non-coplanar diff pair): width: 6.2300 mils (0.1583 mm) spacing: 8 mils (0.2032 mm)

Parts:
C5, C7: 100nF 16V; C_0603_1608Metric; MPN C0805C104K4RACTU
C11: 10uF 16V; C_0603_1608Metric; MPN CL21A106KOFNNNE
D2: LED_Dual_AAKK; LED_Dual_RG_discrete
R9: 10K; R_0603_1608Metric
U8: SN74AHCT125PWR; SSOP-14_5.3x6.2mm_P0.65mm; MPN SN74AHCT125N; Digi-Key_PN 296-4655-5-ND
U9: MAX7219CWG; SOIC-24W_7.5x15.4mm_P1.27mm; MPN MAX7219CWG
U10: Lite-on LTP747KR; DIP-12_W7.62mm_right_angle; MPN LTP747KR

Connections:
/MOSI: U8.12 (4A); also elsewhere on the board
/NSS: U8.5 (2A); also elsewhere on the board
/SAFE_5V: C5.1, C7.1, C11.2, R9.1, U8.14 (VCC), U9.19 (V+); also elsewhere on the board
/SCK: U8.9 (3A); also elsewhere on the board
GND: C5.2, C7.2, C11.1, U8.1 (1~OE), U8.2 (1A), U8.4 (2~OE), U8.7 (GND), U8.10 (3~OE), U8.13 (4~OE), U9.4 (GND), U9.9 (GND); also elsewhere on the board
unnamed: D2.1 (A1), U9.14 (SEG_A)
unnamed: D2.2 (A2), U9.16 (SEG_B)
unnamed: D2.3 (K1), D2.4 (K2), U9.8 (DIG_7)
unnamed: U8.6 (2Y), U9.12 (LOAD)
unnamed: U8.8 (3Y), U9.13 (CLK)
unnamed: U8.11 (4Y), U9.1 (DIN)
unnamed: R9.2, U9.18 (ISET)
unnamed: U9.17 (SEG_G), U10.1 (ac1)
unnamed: U9.15 (SEG_F), U10.3 (ac2)
unnamed: U9.21 (SEG_E), U10.10 (ac3)
unnamed: U9.23 (SEG_D), U10.7 (ac4)
unnamed: U9.20 (SEG_C), U10.8 (ac5)
unnamed: U9.2 (DIG_0), U10.12 (cr1)
unnamed: U9.11 (DIG_1), U10.11 (cr2)
unnamed: U9.6 (DIG_2), U10.2 (cr3)
unnamed: U9.7 (DIG_3), U10.9 (cr4)
unnamed: U9.3 (DIG_4), U10.4 (cr5)
unnamed: U9.10 (DIG_5), U10.5 (cr6)
unnamed: U9.5 (DIG_6), U10.6 (cr7)

Notes on the sheet:
green
red
5x7 LED matrix anode column, cathode row

Board: 4 copper layers, 159.9 x 99.9 mm, 78 parts (5 on the bottom side), 98 nets.

## KiCad design hardware/pi5_adapter/pi5_adapter.kicad_pcb

Parts:
C1: 100n
C2: 1uF
J1, J2: GPIO
J3: Conn_01x05
J5: Conn_02x05_Odd_Even
JP1: ID_WP
JP2: BYPASS
R1, R2: 3.9k
R3, R4, R5: 10K
R6, R7: 0R
U1: CAT24C256
U2: TPS27081ADDCR; SOT-23-6; MPN TPS27081ADDCR; Digi-Key_PN 296-34970-1-ND

Connections:
+3.3V: C1.1, J1.1, J1.17, J2.1, J2.17, JP1.2 (B), R1.1, R2.1, R5.2, U1.8 (VCC)
+5V: J1.2, J1.4, JP2.2 (B), U2.2 (VOUT), U2.3 (VOUT)
/5V_EXTERNAL: C2.1, J2.2, J2.4, JP2.1 (A), R3.2, R4.1, U2.4 (VIN)
/CONSOLE_RX: J3.4, J5.7, R6.2
/CONSOLE_TX: J3.5, J5.9, R7.2
/GLOBAL_EN: J3.2, J5.3, R4.2, U2.5 (ON/OFF)
/GPIO2/SDA1: J1.3, J2.3
/GPIO3/SCL1: J1.5, J2.5
/GPIO4/GPCLK0: J1.7, J2.7
/GPIO5: J1.29, J2.29
/GPIO6: J1.31, J2.31
/GPIO7/SPI0.CE1: J1.26, J2.26
/GPIO8/SPI0.CE0: J1.24, J2.24
/GPIO9/SPI0.MISO: J1.21, J2.21
/GPIO10/SPI0.MOSI: J1.19, J2.19
/GPIO11/SPI0.SCLK: J1.23, J2.23
/GPIO12/PWM0: J1.32, J2.32
/GPIO13/PWM1: J1.33, J2.33
/GPIO14/TXD0: J1.8, J2.8, R6.1
/GPIO15/RXD0: J1.10, J2.10, R7.1
/GPIO16: J1.36, J2.36
/GPIO17: J1.11, J2.11
/GPIO18/PCM.CLK: J1.12, J2.12
/GPIO19/PCM.FS: J1.35, J2.35
/GPIO20/PCM.DIN: J1.38, J2.38
/GPIO21/PCM.DOUT: J1.40, J2.40
/GPIO22: J1.15, J2.15
/GPIO23: J1.16, J2.16
/GPIO24: J1.18, J2.18
/GPIO25: J1.22, J2.22
/GPIO26: J1.37, J2.37
/GPIO27: J1.13, J2.13
/ID_SCL: J1.28, J2.28, R2.2, U1.6 (SCL)
/ID_SDA: J1.27, J2.27, R1.2, U1.5 (SDA)
/RUN_PG: J3.1, J5.1, R5.1
GND: C1.2, C2.2, J1.6, J1.9, J1.14, J1.20, J1.25, J1.30, J1.34, J1.39, J2.6, J2.9, J2.14, J2.20, J2.25, J2.30, J2.34, J2.39, J3.3, J5.5, U1.4 (GND), U2.1 (R2)
unnamed: JP1.1 (A), U1.7 (WP)
unnamed: R3.1, U2.6 (R1/C1)

Notes on the sheet:
External connectors
DNP
Internal connectors
Additional pin functions: https://pinout.xyz/
ID_SD and ID_SC PINS: These pins are reserved for HAT ID EEPROM. At boot time this I2C interface will be interrogated to look for an EEPROM that identifes the attached board and allows automagic setup of the GPIOs (and optionally, Linux drivers). Bridging JP1 enables write protection. DO NOT USE th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
3A high side power switch R_{on} typical 32mΩ Drop voltage at 5.5V: 0.03V (1A, 25°C) 0.04V (1A, 85°C) 0.07V (2A, 25°C) 0.08V (2A, 85°C) 0.10V (3A, 25°C)

Notices in the files:
firmware/src/i2c.c:
Copyright 2023 Jim Garlick <garlick.jim@gmail.com>
hardware/pi-carrier/eurocard.kicad_pcb:
(c) 2020 WorlickWerx
hardware/pi-power/pi-power.kicad_pcb:
CERN-OHL-1.2
