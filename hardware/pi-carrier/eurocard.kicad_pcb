# Repository worlickwerx/pi-cluster-two (continued)

## KiCad design hardware/bus-3/bus-3.kicad_pcb (continued)

Board: 2 copper layers, 72.8 x 128.8 mm, 20 parts (17 on the bottom side), 89 nets.

## KiCad design hardware/pi-power/pi-power.kicad_pcb

Board: 2 copper layers, 21.3 x 31.5 mm, 13 parts (2 on the bottom side), 12 nets.

Parts:
C1, C2, C3: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: LED; LED_0805_2012Metric
J1, J3: Conn_01x12_Male; PinHeader_1x12_P2.54mm_Vertical
R2: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3: 0.1; R_2512_6332Metric_Pad1.52x3.35mm_HandSolder
R4: 330; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: 74AUP1G74; VSSOP-8_2.3x2mm_P0.5mm
U2: TPS27081ADDCR; SOT-23-6
U3: INA169NA_3K; SOT-753

Connections:
+5V: C3.1, C4.1, J3.7, J3.8, R2.2, U2.4
/PWR_5V_OUT: J3.11, J3.12, R3.1, R4.1, U3.4
/PWR_MEAS: J3.9, U3.1
/PWR_STATE: J1.3, U1.5, U2.5
/PWR_TOGGLE: J1.4, U1.1
/~RESET~: J1.5, U1.6
GND: C1.2, C2.2, C3.2, C4.2, D1.1, J1.12, U1.4, U2.1, U3.2
unnamed: D1.2, R4.2
unnamed: R2.1, U2.6
unnamed: R3.2, U2.2, U2.3, U3.3
unnamed: U1.2, U1.3
VCC: C1.1, C2.1, J1.6, U1.7, U1.8, U3.5

## Code that names these connections

File firmware/src/i2c.c (part):

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 * The RTC registers (0x00 - 0x06) track the firmware wall clock.
 * hwclock(8) may be used to get and put the time/date via the linux driver.
 *
 * PB10 - SCL (connected to pi GPIO3)
 * PB11 - SDA (connected to pi GPIO2)
 *
 * Notes:
 * - See note in matrix.c about SMBA conflict on PB12 (worked around there).
 * - the DS1307 control register (0x07) is unimplemented
 */

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    gpio_set_mode (GPIOB,
                   GPIO_MODE_OUTPUT_50_MHZ,
                   GPIO_CNF_OUTPUT_ALTFN_OPENDRAIN,
                   GPIO_I2C2_SCL | GPIO_I2C2_SDA); // PB10, PB11

    i2c_reset (I2C2);
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
## Commit log (part)

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2020-12-19 firmware/canbus: enable auto bus off management
    Problem: Auto bus off can disconnect us from bus if error count
    reaches a threshold. Since ABOM is off, there is no recovery.
    Enable ABOM.
2020-12-23 firmware/i2c: enable matrix update
    Display the 'F' (0x46) character on the LED matrix:
    i2cset 1 0xe30 13 0x46
    Set all LEDs in the matrix
    i2cset 1 0x30 12 0x7f 0x7f 0x7f 0x7f 0x7f i
    Clear all LEDs in the matrix
    i2cset 1 0x30 12 0 0 0 0 0 i
2020-12-27 cm4-compute: begin schematic for GPIO portion
2020-12-28 cm4-compute: drop SD card symbol from schematic
2020-12-31 cm4-compute: add M.2 to board
2021-01-11 firmware: disable serial while unconnected
    Problem: when user connects to console, they see
    a buffer worth of backlog.
    This seems wrong. Disable serial capture when there
    is no connection.
2021-01-16 firmware: fix whitespsace in FreeRTOSConfig.h
2021-01-16 firmware: refactor canbus
    Problem: canbus.c has grown too complicated.
    Split the canmsg_v1 service implementations to canservice.c.
2021-01-21 drivers: add CAN device tree overlay
    Import mcp2515-can0-overlay.dts from raspberry pi linux-5.10
    source tree and modify for SPI bus 1, device 0.
    Enable with the following in config.txt:
    dtparam=spi=on
    dtoverlay=spi1-1cs
    dtoverlay=mcp2515-can2,interrupt=12
2021-01-23 libbramble/canlinux: clear xmsgidf on SFF frame receipt
    Problem: xmsgidf is set on both size IDs.
    Fix logic.
2021-01-23 libbramble: add canobj
2021-01-24 bramble: allow BRAMBLE_SLOT environment var
    Problem: bramble can utils won't work on a board that doesn't
    have the STM32 processor connected with I2C, because it cannot
    determine its address.
    If BRAMBLE_SLOT is set in the environment, override the I2C.
2021-01-24 bramble/console: ignore non-console messages
2021-02-02 firmware: convert to v2 CAN protocol
2021-02-03 README.md: update firmware status
2021-02-07 bramble: install CAN filters
    Problem: the raw CAN interface is configured without filters,
    causing unnecessary wake-ups for CAN processes such as the power
    and console helpers.
    Add an argument to can_open() to allow the local address to be
    specified, and then install filters for that destination address
    and the broadcast address.
2021-02-07 firmware/console: allow multiple DAT per ACK
    Problem: the serial console buffer can be overrun due to
    lock-step DAT/ACK protocol.
    While the serial buffer has data, send up to 16 sequenced DAT
    messages back to back before requiring an ACK by setting eot=1.
    This implementation is still not optimal since transmission
    pauses after the 16th DAT is sent, waiting for the ACK, rather
2021-04-18 firmware/blink: change RTOS LED duty cycle
    Problem: green light is spending too much time on.
    It's annoying.
    Instead of toggling the LED every 500ms, turn it on for
    1ms and then off for 2000ms.
2022-03-05 firmware: add some notes on building the firwmare
    Problem: I have to keep looking stuff up to remember how to
    build the firmware.
    Add some notes in a markdown file.
2022-03-19 bramble: add systemd unit file
    Problem: bramble usage-bargraph has to be started manually
    with a pdsh.
    Add a systemd unit file that runs bramble usage-bargraph
    when the system boots.
    Add some helpful m4 macros to:
    - help autotools grok systemd
2022-03-25 firmware: keep wall clock time
    Problem: we need to track the wall clock for RTC emulation.
    The STM32 RTC hardware can keep time across a power cycle IFF:
    - VBAT is powered
    - LSE clock source is used
    however pi carrier v2 does not wire VBAT, nor drive the OSC32 XTAL
    inputs used for the LSE clock. The LSE is the only clock source
2022-06-15 bramble: add shutdown subcommand
    Problem: there is no way to exercise CAN SHUTDOWN object.
    Add 'bramble shutdown SLOT' which:
    1. sets the SHUTDOWN object to 1, which triggers the gpio-shutdown
    overlay on the pi, causing systemd to receive a poweroff keypress
    2. polls the SHUTDOWN object periodically until a 1 is read, which
    indicates that the OS has shut down.
2022-06-19 pi-carrier: convert board to kicad 6
    Problem: pi-carrier was created under kicad 5 but 6 is now the current
    version.
    Save eurocard.kicad_pcb under kicad 6.
2022-06-25 firmware: drop power flip flop
    Problem: the power flip flop is no longer needed, since we
    can tell the difference between a power on reset and other types
    of reset by testing (RCC_CSR & PORRSTF).
    Change pi power control code to use that technique instead of the
    flip flop, which may be removed from future designs.
2022-06-26 pi-carrier: change holes for pi mounting hardware
    Problem: mounting holes for pi bracket are not currently used.
    Drop one mounting hole.
    Add two stablization holes for a new bracket (TBD).
2022-06-26 pi-carrier: fix JST schematic symbol
    Problem: Schematic symbol for 3 pin JST connectors do not include
    mounting terminals.
    Change to symbol with mounting terminals and tie to ground plane.
2022-06-26 pi-carrier: drop header for comms pins
    Problem: header for comms pins is unused.
    Drop header.
2022-06-27 pi-carrier: drop disconnected flag on unused power
    Problem: ERC fails on unused bus power pins because they are
    marked disconnected, but are ganged in the symbol.
    Drop disconected flag.
2022-06-27 pi-carrier: fix U8 footprint
    Problem: U8 was assigned a footprint from an external digikey
    library, then we assigned the wrong native one on converting
    to kicad 6.
    Select the correct native footprint.
2022-06-27 pi-carrier: add track width to pull down
2022-06-29 pi-carrier: change 32.768khz xtal footprint
    Problem: rtc xtal is too big
    Go with Abracon ABS07-32.768KHZ-T (in stock at digikey).
2022-06-29 pi-carrier: add more test points
    Problem: some key probing points are still inaccessible.
    Expand test points. Change "value" field to match function.
2022-07-04 pi-carrier: fix footprint etc
2022-07-04 footprints: fix right angle matrix socket
    Problem: there was a garbage 3d reference in footprint attrs.
    Remove garbage refs
2022-07-07 pi-carrier: update 3d image
2022-07-30 hardware: add pi front panel
    Problem: pi carrier 3d printed PLA front panel is not sufficiently
    rigid and does not support an ejector lever.
    Have a go at converting the kludge card PCB front panel for use
    with the pi-carrier. The pi holes are in a separate footprint,
    since it was easier to translate the FreeCAD parameters to a zero
    origin footprint.
2023-06-16 firmware: tidy up power initialization and document
    Problem: power control initialization is sparsely documented.
    Add some inline docs and reorganize the code for readability.
2023-12-29 doc: add copyright header to sources
    Problem: copyright is missing from source code.
    Add a boiler plate copyright header to the original *.[ch].
2023-12-30 build: add bramble-fw-update script
    Problem: a firmware update currently requires the source
    tree to be present.
    Install a script for updating the firwmare from /lib/bramble.fw.
    Also: add a 'make flash' target in the firmware directory that
    calls this script.
2024-01-08 firmware: clear address from matrix after 2s
    Problem: when a pi is off for a long time, leaving the bus
    address up there just wastes power and looks dumb.
    Clear it after 2s.
2024-01-15 pi-carrier: fix ERC errors
    Problem: several bus power pins were labeled but unconnected.
    Drop labels and wires on those pins and mark 'X' (NC).
2024-01-15 pi-carrier: update to kicad 7.0.9
    Problem: pi-carrier was developed with kicad 6.
    Open the project in kicad-7.0.9~ubuntu22.04.1 and save it.
2024-01-15 pi-carrier: fix board short
    Problem: a DRC error calls out a clearance violation at the J2
    debug connector.
    Relocate 3V3 power trace to avoid JST footprint.
    Fix resulting ground plane split.
2024-01-16 pi4_panel_4hp: rename from pi_carrier_panel_4hp
    Problem: panel project name is too long
    Shorten it.
2024-02-17 Revert "firmware: add pi 5 power control support"
    Problem: the problem of the pi 5's power button has been solved
    with the addition of a load switch on the adapter board, so
    the clunky firmware changes are no longer needed.
    Moreover, the load switch works with the older pi's.
    This reverts commit a02747ab8d2630805885d843114568900f7e5cc8.
2024-02-17 pi-carrier: fix console label
    Problem: console label did not show up on silk
    Same problem as with the test points in the last commit, and same fix.
    Add a separate descriptive silk label.
2024-02-18 pi-carrier: add sdcard pic on back of board
    Problem: earlier designs have placed obstacles in the way of
    inserting the sdcard.
    Add an sdcard image to the silk layer to hopefully prevent that sort
    of error in the future.
2024-02-20 pi-carrier: reroute pi GPIO lines
    Problem: pi GPIO traces are inefficiently routed and are crossing
    the area on the front fo the board where M.2 traces will go.
    Reroute.
2024-02-20 pi-carrier: update M.2 power circuit
    Problem: oops, TI buck converter is obsolete.
    Use the pin-compatible replacement, TPS563203.
    Adjust recommended component values for 3V3 and add some
    more passives per the new spec sheet.
2024-02-26 pi-carrier: fix efuse powerpad signal type
    Problem: the efuse has a "powerpad" on the bottom that is
    labeled as a bidirectional pin but should be grounded.
    Fix the symbol to make that a power pin.
    Also drop the symbol's implicit connection to a nonexistent footprint.
2024-02-26 pi-carrier: fix efuse schematic formatting
    Problem: a subscript in notes is not formatted correctly.
    Fix formatting.
2024-02-26 pi-carrier: address pcbway concnern
    Problem: pcbway enginner says differential clock signal is
    too close the the board edge and must be >= 0.15mm.
    Move pcie clock away from board edge.
2024-03-18 build: add hardware configure logic
    Problem: kicad-cli in version 8 allows ERC/DRC and CAM generation
    to be run programmatically, but our build system does not take
    advantage of that.
    Add configure logic in the hardare subdirectory that looks for
    an appropriately recent version of kicad.
    If --with-kicad is specified, not finding one is an error.
2024-03-18 pi5_adapter: fix board DRC errors
    Problem: schematic fails DRC
    Add lib.pretty library (containing 5 pin SIP connector).
    Update all symbols from library.
    Remove stray board edge line.
2024-03-19 pi5_adapter: add fp-lib-table, sym-lib-table
    Problem: fp-lib-table and sym-lib-table should have been checked
    into git.
    Add them.
2024-04-14 pi-carrier: flip M.2 slot upside-down and reroute
    Problem: the differential traces for the M.2 slot are longer
    than they need to be, and impedance needs to be recalculated
    for the 4-layer board.
    Use JLPCB's recommended trace width of 6.1200 mils (0.1555 mm)
    and spacing of 8.0000 mils (0.2032 mm) for 90 ohms using their
    default 4-layer stackup.
2024-04-20 pi-carrier: refine pcie diff pair routing
    Problem: top copper clearance for pcie diff pairs is too small.
    Give each pair 5 times the trace width (0.7925 mm) on each side.
    Also: add F.Fab notes about desired impedance.
2024-04-21 pi-carrier: improve clearance on diffpair tracks
    Problem: there is not enough clearance between pcie signals
    and the edge of the board.
    Reroute traces and adjust keepouts to ensure a minimum of 0.7915mm
    between traces and top ground plane or board edge. Shrink keepouts
    in other places to reduce the clearance to around that.
2024-04-23 pi5_adapter: update symbols
    Problem: kicad 8.0.1 is throwing ERC errors about out of date
    symbols.
    Update symbols.
2024-04-27 pi-carrier: update 3d view
