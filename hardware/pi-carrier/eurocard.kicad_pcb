# Repository worlickwerx/pi-cluster-two (continued)

## KiCad design hardware/pi5_adapter/pi5_adapter.kicad_pcb (continued)

Board: 2 copper layers, 65.0 x 74.0 mm, 24 parts (4 on the bottom side), 38 nets.

Other parts of the board:
MH1, MH1#2, MH1#3, MH2, MH3, MH4, MH4#2: MountingHole_2.7mm_M2.5

## KiCad design hardware/cm4-compute/cm4-compute.kicad_pcb

Board: 2 copper layers, 160.0 x 100.0 mm, 6 parts (0 on the bottom side), 14 nets, no tracks yet.

Parts:
H1, H2, H3: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad_TopBottom
J1: M.2_Key_M_Socket_3_PCIe; Conn_TE-M.2-0.5-67P-doublesided
Module1: ComputeModule4-CM4; rpiCM4
R1: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
/M.2 expansion/PCIE_3V3: J1.2, J1.4, J1.12, J1.14, J1.16, J1.18, J1.70, J1.72, J1.74, R1.2
/M.2 expansion/PCIE_CLK+: J1.55, Module1.110
/M.2 expansion/PCIE_CLK-: J1.53, Module1.112
/M.2 expansion/PCIE_RX+: J1.49, Module1.116
/M.2 expansion/PCIE_RX-: J1.47, Module1.118
/M.2 expansion/PCIE_TX+: J1.43, Module1.122
/M.2 expansion/PCIE_TX-: J1.41, Module1.124
/M.2 expansion/~PCIE_CLK_REQ~: J1.52, Module1.102
/M.2 expansion/~PCIE_RST~: J1.50, Module1.109
/cm4_gpio/+3V3: Module1.84, Module1.86
/cm4_gpio/+5V: Module1.77, Module1.79, Module1.81, Module1.83, Module1.85, Module1.87
GND: H1.1, H2.1, H3.1, J1.1, J1.3, J1.9, J1.15, J1.21, J1.27, J1.33, J1.39, J1.45, J1.51, J1.57, J1.71, J1.73, J1.75, Module1.1, Module1.2, Module1.7, Module1.8, Module1.13, Module1.14, Module1.22, Module1.23, Module1.32, Module1.33, Module1.42, Module1.43, Module1.52, Module1.53, Module1.59, Module1.60, Module1.65, Module1.66, Module1.71, Module1.74, Module1.98, Module1.107, Module1.108, Module1.113, Module1.114, Module1.119, Module1.120, Module1.125, Module1.126, Module1.131, Module1.132, Module1.137, Module1.138, Module1.144, Module1.150, Module1.155, Module1.156, Module1.161, Module1.162, Module1.167, Module1.168, Module1.173, Module1.174, Module1.179, Module1.180, Module1.185, Module1.186, Module1.191, Module1.192, Module1.197, Module1.198
unnamed: J1.6, J1.8, J1.20, J1.22, J1.24, J1.26, J1.28, J1.30, J1.32, J1.34, J1.36, J1.38, J1.40, J1.42, J1.44, J1.46, J1.48, J1.59, J1.60, J1.61, J1.62, J1.63, J1.64, J1.65, J1.66, J1.67
unnamed: J1.54, R1.1

## KiCad design hardware/supervisor/supervisor.kicad_pcb

File hardware/supervisor/README.md:

## supervisor

Supervisor card, which attaches to backplane using 14-pin ribbon cable.
The supervisor runs on standby power and controls crate power, three fans,
bus reset, and terminates wired-OR barrier network.  The supervisor also
performs monitoring and admin tasks on the CAN bus, which may be accessed
through a front panel RJ12 jack.

Front view:

Back view:

See also:
* [schematic](schematic.pdf)

Board: 2 copper layers, 40.0 x 100.1 mm, 55 parts (32 on the bottom side), 57 nets.

Parts:
C1: 100uF 16V; CP_Elec_6.3x7.7
C2: 10uF 16V; C_0805_2012Metric
C3: 22uF 16V; C_0805_2012Metric
C4, C5, C6, C7, C8, C9, C10, C13, C14, C15, C16, C18: 100nF 16V; C_0805_2012Metric
C11, C12: 22pF; C_0805_2012Metric
C17: 1uF 16V; C_0805_2012Metric
D1: LED GREEN; LED_0805_2012Metric
D2: LED_Dual_AACC; LED_Dual_RG_discrete
F1: PTC 1A 6V; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
F2: PTC 2.5A 16V; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
J1: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J2: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J3: Conn_02x07_Odd_Even; IDC-Header_2x07_P2.54mm_Latch_Horizontal
J4: RJ12; RJ12_Amphenol_54601
M1, M2, M3: Fan_4pin; FanPinHeader_1x04_P2.54mm_Vertical
R1, R3, R4, R5, R6, R10, R13, R14, R15, R16: 10K; R_0805_2012Metric
R2, R7, R8: 510; R_0805_2012Metric
R9: 390; R_0805_2012Metric
R11: 100K; R_0805_2012Metric
SW1, SW3: SW_Push; SW_Tactile_SPST_Angled_PTS645Vx83-2LFS
U1, U8: SN74LVC07ADB; SSOP-14_5.3x6.2mm_P0.65mm
U2: TCAN332DR; SOT-23-8
U3: LM1117-IMPX3.3; SOT-223-3_TabPin2
U4: SN74LVC1G86DBV; SOT-23-5
U5: SN74LVC2G74DCUR; VSSOP-8_2.3x2mm_P0.5mm
U6: STM32F103C8T6; LQFP-48_7x7mm_P0.5mm
U7: CAT811TTBI-GT3; SOT-143
Y1: 8Mhz; Crystal_HC49-4H_Vertical

Connections:
+3V3: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C13.1, C14.1, C15.1, C16.1, C17.1, D1.2, D2.1, D2.2, J2.2, R1.1, R3.1, R4.1, R5.2, R6.2, R10.1, R13.1, R14.1, R15.1, R16.2, U1.14, U2.3, U3.2, U4.5, U5.8, U6.1, U6.9, U6.24, U6.36, U6.48, U7.4, U8.14
+12V: F2.1, M1.2, M2.2, M3.2
/5V: J1.5, J1.6, J3.8
/5V_SB: J1.1, J1.2, J3.4
/5V_SRC: F1.2, J1.3, J1.4
/12V: F2.2, J3.2
/BOOT0: J2.9, R6.1, U6.44
/BOOT1: J2.11, R5.1, U6.20
/CAN+: J3.5, J4.3, U2.7
/CAN-: J3.3, J4.4, U2.6
/CANRX: U2.4, U6.45
/CANTX: U2.1, U6.46
/CRA0: J2.13, U6.25
/CRA1: J2.15, U6.26
/CRA2: J2.17, U6.27
/CRA3: J2.19, U6.28
/FAN1_PWM: U6.10, U8.3
/FAN1_TACH: U6.13, U8.2
/FAN2_PWM: U6.11, U8.9
/FAN2_TACH: U6.14, U8.6
/FAN3_PWM: U6.12, U8.13
/FAN3_TACH: U6.15, U8.10
/LED_POWER: R2.1, U6.4
/OR_INA: J3.9, R3.2, U4.1, U5.2
/OR_INB: J3.11, R4.2, U4.2
/OR_OUT: J3.13, U5.5
/PC13: R8.1, U6.2
/PWR_OK: J1.7, J3.6, U1.1
/PWR_SWITCH: SW1.2, U6.18
/SCL: J2.6, U6.21
/SDA: J2.4, U6.22
/SWCLK: J2.5, U6.37
/SWDIO: J2.3, U6.34
/SWO: J2.1, U6.39
/~BUS_RESET~: J3.7, R16.1, U1.2, U1.4
/~PS_ON~: J1.9, J3.10, U1.6
/~RESET~: C18.2, U1.8, U5.6, U6.7
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.1, J1.10, J2.7, J2.8, J2.10, J2.12, J2.14, J2.16, J2.18, J2.20, J3.14, J4.5, M1.1, M2.1, M3.1, R7.1, R11.1, SW1.1, SW3.1, U1.7, U1.11, U1.13, U2.2, U3.1, U4.3, U5.4, U6.8, U6.23, U6.35, U6.47, U7.1, U8.7
unnamed: C1.1, C2.1, F1.1, U3.3
unnamed: C11.1, U6.5, Y1.1
unnamed: C12.1, R9.2, Y1.2
unnamed: D1.1, R8.2
unnamed: D2.3, R2.2
unnamed: D2.4, R7.2
unnamed: J1.8, R1.2
unnamed: M1.3, R13.2, U8.1
unnamed: M1.4, U8.4
unnamed: M2.3, R14.2, U8.5
unnamed: M2.4, U8.8
unnamed: M3.3, R15.2, U8.11
unnamed: M3.4, U8.12
unnamed: R9.1, U6.6
unnamed: R10.2, U5.7
unnamed: R11.2, U1.3, U1.9, U7.2
unnamed: SW3.2, U7.3
unnamed: U1.5, U6.32
unnamed: U4.4, U5.1

## KiCad design hardware/bus-8/bus-8.kicad_pcb

File hardware/bus-8/README.md:

## bus-8

An 8-slot bus, suitable for 4, 4 x 4, and 4 x 4 x 4 node configurations.

Front view:

Back view:

See also:
* [schematic](schematic.pdf).
* [layout](layout.pdf).
* [molliebus pinout](molliebus.pdf).

Board: 2 copper layers, 198.9 x 128.6 mm, 88 parts (79 on the bottom side), 287 nets.

Parts:
J1, J2, J3, J4, J5, J6, J7, J8: C96ABC; DIN41612_C_3x32_Female_Vertical_THT
J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28, J29, J30, J31, J32, J33, J34, J35, J36, J37, J38, J39, J40, J41, J42, J43, J44, J45, J46, J47, J48, J49, J50, J51, J52, J53, J54, J55, J56, J57, J58, J59, J60, J61, J62, J63, J64: Conn_01x04; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J65: ATX-20; Molex_Mini-Fit_Jr_5566-20A_2x10_P4.20mm_Vertical
J66, J67: Conn_02x07_Odd_Even; IDC-Header_2x07_P2.54mm_Latch6.5mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R1, R2: 120 0.25W; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
e: MountingHole_2.7mm_M2.5_DIN965

Connections:
/3V3: J1.A13, J1.B13, J1.C13, J2.A13, J2.B13, J2.C13, J3.A13, J3.B13, J3.C13, J4.A13, J4.B13, J4.C13, J5.A13, J5.B13, J5.C13, J6.A13, J6.B13, J6.C13, J7.A13, J7.B13, J7.C13, J8.A13, J8.B13, J8.C13, J65.1, J65.2, J65.11, J66.12
/5V: J1.A1, J1.A32, J1.B1, J1.B32, J1.C1, J1.C32, J2.A1, J2.A32, J2.B1, J2.B32, J2.C1, J2.C32, J3.A1, J3.A32, J3.B1, J3.B32, J3.C1, J3.C32, J4.A1, J4.A32, J4.B1, J4.B32, J4.C1, J4.C32, J5.A1, J5.A32, J5.B1, J5.B32, J5.C1, J5.C32, J6.A1, J6.A32, J6.B1, J6.B32, J6.C1, J6.C32, J7.A1, J7.A32, J7.B1, J7.B32, J7.C1, J7.C32, J8.A1, J8.A32, J8.B1, J8.B32, J8.C1, J8.C32, J65.4, J65.6, J65.19, J65.20, J66.8
/5V_SB: J65.9, J66.4
/12V: J1.A3, J1.B3, J1.C3, J2.A3, J2.B3, J2.C3, J3.A3, J3.B3, J3.C3, J4.A3, J4.B3, J4.C3, J5.A3, J5.B3, J5.C3, J6.A3, J6.B3, J6.C3, J7.A3, J7.B3, J7.C3, J8.A3, J8.B3, J8.C3, J65.10, J66.2
/CAN+: J1.A5, J2.A5, J3.A5, J4.A5, J5.A5, J6.A5, J7.A5, J8.A5, J66.5, J67.5, R1.1, R2.1
/CAN-: J1.A4, J2.A4, J3.A4, J4.A4, J5.A4, J6.A4, J7.A4, J8.A4, J66.3, J67.3, JP17.1, JP18.2
/DOWN_RX0+: J1.C20, J12.3
/DOWN_RX0-: J1.C21, J12.4
/DOWN_RX1+: J2.C20, J19.3
/DOWN_RX1-: J2.C21, J19.4
/DOWN_RX2+: J3.C20, J26.3
/DOWN_RX2-: J3.C21, J26.4
/DOWN_RX3+: J4.C20, J33.3
/DOWN_RX3-: J4.C21, J33.4
/DOWN_RX4+: J5.C20, J40.3
/DOWN_RX4-: J5.C21, J40.4
/DOWN_RX5+: J6.C20, J47.3
/DOWN_RX5-: J6.C21, J47.4
/DOWN_RX6+: J7.C20, J54.3
/DOWN_RX6-: J7.C21, J54.4
/DOWN_RX7+: J8.C20, J61.3
/DOWN_RX7-: J8.C21, J61.4
/DOWN_TX0+: J1.C18, J12.1
/DOWN_TX0-: J1.C19, J12.2
/DOWN_TX1+: J2.C18, J19.1
/DOWN_TX1-: J2.C19, J19.2
/DOWN_TX2+: J3.C18, J26.1
/DOWN_TX2-: J3.C19, J26.2
/DOWN_TX3+: J4.C18, J33.1
/DOWN_TX3-: J4.C19, J33.2
/DOWN_TX4+: J5.C18, J40.1
/DOWN_TX4-: J5.C19, J40.2
/DOWN_TX5+: J6.C18, J47.1
/DOWN_TX5-: J6.C19, J47.2
/DOWN_TX6+: J7.C18, J54.1
/DOWN_TX6-: J7.C19, J54.2
/DOWN_TX7+: J8.C18, J61.1
/DOWN_TX7-: J8.C19, J61.2
/GA3_0: J1.A9, JP1.1
/GA3_1: J2.A9, JP2.1
/GA3_2: J3.A9, JP3.1
/GA3_3: J4.A9, JP4.1
/GA3_4: J5.A9, JP5.1
/GA3_5: J6.A9, JP6.1
/GA3_6: J7.A9, JP7.1
/GA3_7: J8.A9, JP8.1
/GA4_0: J1.A10, JP9.1
/GA4_1: J2.A10, JP10.1
/GA4_2: J3.A10, JP11.1
/GA4_3: J4.A10, JP12.1
/GA4_4: J5.A10, JP13.1
/GA4_5: J6.A10, JP14.1
/GA4_6: J7.A10, JP15.1
/GA4_7: J8.A10, JP16.1
/IN_RX0+: J1.C6, J9.3
/IN_RX0-: J1.C7, J9.4
/IN_RX1+: J2.C6, J16.3
/IN_RX1-: J2.C7, J16.4
/IN_RX2+: J3.C6, J23.3
/IN_RX2-: J3.C7, J23.4
/IN_RX3+: J4.C6, J30.3
/IN_RX3-: J4.C7, J30.4
/IN_RX4+: J5.C6, J37.3
/IN_RX4-: J5.C7, J37.4
/IN_RX5+: J6.C6, J44.3
/IN_RX5-: J6.C7, J44.4
/IN_RX6+: J7.C6, J51.3
/IN_RX6-: J7.C7, J51.4
/IN_RX7+: J8.C6, J58.3
/IN_RX7-: J8.C7, J58.4
/IN_TX0+: J1.C4, J9.1
/IN_TX0-: J1.C5, J9.2
/IN_TX1+: J2.C4, J16.1
/IN_TX1-: J2.C5, J16.2
/IN_TX2+: J3.C4, J23.1
/IN_TX2-: J3.C5, J23.2
/IN_TX3+: J4.C4, J30.1
/IN_TX3-: J4.C5, J30.2
/IN_TX4+: J5.C4, J37.1
/IN_TX4-: J5.C5, J37.2
/IN_TX5+: J6.C4, J44.1
/IN_TX5-: J6.C5, J44.2
/IN_TX6+: J7.C4, J51.1
/IN_TX6-: J7.C5, J51.2
/IN_TX7+: J8.C4, J58.1
/IN_TX7-: J8.C5, J58.2
/LEFT_RX0+: J1.A27, J4.C27
/LEFT_RX0-: J1.A28, J4.C28
/LEFT_RX1+: J1.C27, J2.A27
/LEFT_RX1-: J1.C28, J2.A28
/LEFT_RX2+: J2.C27, J3.A27
/LEFT_RX2-: J2.C28, J3.A28
/LEFT_RX3+: J3.C27, J4.A27
/LEFT_RX3-: J3.C28, J4.A28
/LEFT_RX4+: J5.A27, J8.C27
/LEFT_RX4-: J5.A28, J8.C28
/LEFT_RX5+: J5.C27, J6.A27
/LEFT_RX5-: J5.C28, J6.A28
/LEFT_RX6+: J6.C27, J7.A27
/LEFT_RX6-: J6.C28, J7.A28
/LEFT_RX7+: J7.C27, J8.A27
/LEFT_RX7-: J7.C28, J8.A28
/LEFT_TX0+: J1.A29, J4.C29
/LEFT_TX0-: J1.A30, J4.C30
/LEFT_TX1+: J1.C29, J2.A29
/LEFT_TX1-: J1.C30, J2.A30
/LEFT_TX2+: J2.C29, J3.A29
/LEFT_TX2-: J2.C30, J3.A30
/LEFT_TX3+: J3.C29, J4.A29
/LEFT_TX3-: J3.C30, J4.A30
/LEFT_TX4+: J5.A29, J8.C29
/LEFT_TX4-: J5.A30, J8.C30
/LEFT_TX5+: J5.C29, J6.A29
/LEFT_TX5-: J5.C30, J6.A30
/LEFT_TX6+: J6.C29, J7.A29
/LEFT_TX6-: J6.C30, J7.A30
/LEFT_TX7+: J7.C29, J8.A29
/LEFT_TX7-: J7.C30, J8.A30
/OR_INA: J1.A15, J2.A15, J3.A15, J4.A15, J5.A15, J6.A15, J7.A15, J8.A15, J66.9, J67.9
/OR_INB: J1.A16, J2.A16, J3.A16, J4.A16, J5.A16, J6.A16, J7.A16, J8.A16, J66.11, J67.11
/OR_OUT: J1.A17, J2.A17, J3.A17, J4.A17, J5.A17, J6.A17, J7.A17, J8.A17, J66.13, J67.13
/OUT_RX0+: J1.C10, J10.3
/OUT_RX0-: J1.C11, J10.4
/OUT_RX1+: J2.C10, J17.3
/OUT_RX1-: J2.C11, J17.4
/OUT_RX2+: J3.C10, J24.3
/OUT_RX2-: J3.C11, J24.4
/OUT_RX3+: J4.C10, J31.3
/OUT_RX3-: J4.C11, J31.4
/OUT_RX4+: J5.C10, J38.3
/OUT_RX4-: J5.C11, J38.4
/OUT_RX5+: J6.C10, J45.3
/OUT_RX5-: J6.C11, J45.4
/OUT_RX6+: J7.C10, J52.3
/OUT_RX6-: J7.C11, J52.4
/OUT_RX7+: J8.C10, J59.3
/OUT_RX7-: J8.C11, J59.4
/OUT_TX0+: J1.C8, J10.1
/OUT_TX0-: J1.C9, J10.2
/OUT_TX1+: J2.C8, J17.1
/OUT_TX1-: J2.C9, J17.2
/OUT_TX2+: J3.C8, J24.1
/OUT_TX2-: J3.C9, J24.2
/OUT_TX3+: J4.C8, J31.1
/OUT_TX3-: J4.C9, J31.2
/OUT_TX4+: J5.C8, J38.1
/OUT_TX4-: J5.C9, J38.2
/OUT_TX5+: J6.C8, J45.1
/OUT_TX5-: J6.C9, J45.2
/OUT_TX6+: J7.C8, J52.1
/OUT_TX6-: J7.C9, J52.2
/OUT_TX7+: J8.C8, J59.1
/OUT_TX7-: J8.C9, J59.2
/PWR_OK: J65.8, J66.6
/TRINA_RX0+: J1.C25, J13.3
/TRINA_RX0-: J1.C26, J13.4
/TRINA_RX1+: J2.C25, J20.3
/TRINA_RX1-: J2.C26, J20.4
/TRINA_RX2+: J3.C25, J27.3
/TRINA_RX2-: J3.C26, J27.4
/TRINA_RX3+: J4.C25, J34.3
/TRINA_RX3-: J4.C26, J34.4
/TRINA_RX4+: J5.C25, J41.3
/TRINA_RX4-: J5.C26, J41.4
/TRINA_RX5+: J6.C25, J48.3
/TRINA_RX5-: J6.C26, J48.4
/TRINA_RX6+: J7.C25, J55.3
/TRINA_RX6-: J7.C26, J55.4
/TRINA_RX7+: J8.C25, J62.3
/TRINA_RX7-: J8.C26, J62.4
/TRINA_TX0+: J1.C23, J13.1
/TRINA_TX0-: J1.C24, J13.2
/TRINA_TX1+: J2.C23, J20.1
/TRINA_TX1-: J2.C24, J20.2
/TRINA_TX2+: J3.C23, J27.1
/TRINA_TX2-: J3.C24, J27.2
/TRINA_TX3+: J4.C23, J34.1
/TRINA_TX3-: J4.C24, J34.2
/TRINA_TX4+: J5.C23, J41.1
/TRINA_TX4-: J5.C24, J41.2
/TRINA_TX5+: J6.C23, J48.1
/TRINA_TX5-: J6.C24, J48.2
/TRINA_TX6+: J7.C23, J55.1
/TRINA_TX6-: J7.C24, J55.2
/TRINA_TX7+: J8.C23, J62.1
/TRINA_TX7-: J8.C24, J62.2
/TRINB_RX0+: J1.A20, J14.3
/TRINB_RX0-: J1.A21, J14.4
/TRINB_RX1+: J2.A20, J21.3
/TRINB_RX1-: J2.A21, J21.4
/TRINB_RX2+: J3.A20, J28.3
/TRINB_RX2-: J3.A21, J28.4
/TRINB_RX3+: J4.A20, J35.3
/TRINB_RX3-: J4.A21, J35.4
/TRINB_RX4+: J5.A20, J42.3
/TRINB_RX4-: J5.A21, J42.4
/TRINB_RX5+: J6.A20, J49.3
/TRINB_RX5-: J6.A21, J49.4
/TRINB_RX6+: J7.A20, J56.3
/TRINB_RX6-: J7.A21, J56.4
/TRINB_RX7+: J8.A20, J63.3
/TRINB_RX7-: J8.A21, J63.4
/TRINB_TX0+: J1.A18, J14.1
/TRINB_TX0-: J1.A19, J14.2
/TRINB_TX1+: J2.A18, J21.1
/TRINB_TX1-: J2.A19, J21.2
/TRINB_TX2+: J3.A18, J28.1
/TRINB_TX2-: J3.A19, J28.2
/TRINB_TX3+: J4.A18, J35.1
/TRINB_TX3-: J4.A19, J35.2
/TRINB_TX4+: J5.A18, J42.1
/TRINB_TX4-: J5.A19, J42.2
/TRINB_TX5+: J6.A18, J49.1
/TRINB_TX5-: J6.A19, J49.2
/TRINB_TX6+: J7.A18, J56.1
/TRINB_TX6-: J7.A19, J56.2
/TRINB_TX7+: J8.A18, J63.1
/TRINB_TX7-: J8.A19, J63.2
/TROUT_RX0+: J1.A25, J15.3
/TROUT_RX0-: J1.A26, J15.4
/TROUT_RX1+: J2.A25, J22.3
/TROUT_RX1-: J2.A26, J22.4
/TROUT_RX2+: J3.A25, J29.3
/TROUT_RX2-: J3.A26, J29.4
/TROUT_RX3+: J4.A25, J36.3
/TROUT_RX3-: J4.A26, J36.4
/TROUT_RX4+: J5.A25, J43.3
/TROUT_RX4-: J5.A26, J43.4
/TROUT_RX5+: J6.A25, J50.3
/TROUT_RX5-: J6.A26, J50.4
/TROUT_RX6+: J7.A25, J57.3
/TROUT_RX6-: J7.A26, J57.4
/TROUT_RX7+: J8.A25, J64.3
/TROUT_RX7-: J8.A26, J64.4
/TROUT_TX0+: J1.A23, J15.1
/TROUT_TX0-: J1.A24, J15.2
/TROUT_TX1+: J2.A23, J22.1
/TROUT_TX1-: J2.A24, J22.2
/TROUT_TX2+: J3.A23, J29.1
/TROUT_TX2-: J3.A24, J29.2
/TROUT_TX3+: J4.A23, J36.1
/TROUT_TX3-: J4.A24, J36.2
/TROUT_TX4+: J5.A23, J43.1
/TROUT_TX4-: J5.A24, J43.2
/TROUT_TX5+: J6.A23, J50.1
/TROUT_TX5-: J6.A24, J50.2
/TROUT_TX6+: J7.A23, J57.1
/TROUT_TX6-: J7.A24, J57.2
/TROUT_TX7+: J8.A23, J64.1
/TROUT_TX7-: J8.A24, J64.2
/UP_RX0+: J1.C16, J11.3
/UP_RX0-: J1.C17, J11.4
/UP_RX1+: J2.C16, J18.3
/UP_RX1-: J2.C17, J18.4
/UP_RX2+: J3.C16, J25.3
/UP_RX2-: J3.C17, J25.4
/UP_RX3+: J4.C16, J32.3
/UP_RX3-: J4.C17, J32.4
/UP_RX4+: J5.C16, J39.3
/UP_RX4-: J5.C17, J39.4
/UP_RX5+: J6.C16, J46.3
/UP_RX5-: J6.C17, J46.4
/UP_RX6+: J7.C16, J53.3
/UP_RX6-: J7.C17, J53.4
/UP_RX7+: J8.C16, J60.3
/UP_RX7-: J8.C17, J60.4
/UP_TX0+: J1.C14, J11.1
/UP_TX0-: J1.C15, J11.2
/UP_TX1+: J2.C14, J18.1
/UP_TX1-: J2.C15, J18.2
/UP_TX2+: J3.C14, J25.1
/UP_TX2-: J3.C15, J25.2
/UP_TX3+: J4.C14, J32.1
/UP_TX3-: J4.C15, J32.2
/UP_TX4+: J5.C14, J39.1
/UP_TX4-: J5.C15, J39.2
/UP_TX5+: J6.C14, J46.1
/UP_TX5-: J6.C15, J46.2
/UP_TX6+: J7.C14, J53.1
/UP_TX6-: J7.C15, J53.2
/UP_TX7+: J8.C14, J60.1
/UP_TX7-: J8.C15, J60.2
/~PS_ON~: J65.14, J66.10
/~RESET~: J1.A14, J2.A14, J3.A14, J4.A14, J5.A14, J6.A14, J7.A14, J8.A14, J66.7, J67.7
GND: J1.A2, J1.A6, J1.A7, J1.A8, J1.A12, J1.A22, J1.A31, J1.B2, J1.B12, J1.B22, J1.B31, J1.C2, J1.C12, J1.C22, J1.C31, J2.A2, J2.A7, J2.A8, J2.A12, J2.A22, J2.A31, J2.B2, J2.B12, J2.B22, J2.B31, J2.C2, J2.C12, J2.C22, J2.C31, J3.A2, J3.A6, J3.A8, J3.A12, J3.A22, J3.A31, J3.B2, J3.B12, J3.B22, J3.B31, J3.C2, J3.C12, J3.C22, J3.C31, J4.A2, J4.A8, J4.A12, J4.A22, J4.A31, J4.B2, J4.B12, J4.B22, J4.B31, J4.C2, J4.C12, J4.C22, J4.C31, J5.A2, J5.A6, J5.A7, J5.A12, J5.A22, J5.A31, J5.B2, J5.B12, J5.B22, J5.B31, J5.C2, J5.C12, J5.C22, J5.C31, J6.A2, J6.A7, J6.A12, J6.A22, J6.A31, J6.B2, J6.B12, J6.B22, J6.B31, J6.C2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
unnamed: JP17.2, R1.2
unnamed: JP18.1, R2.2

## KiCad design hardware/bus-3/bus-3.kicad_pcb

Parts:
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1, J2: Conn_02x01; PinHeader_2x01_P2.54mm_Vertical
J3: Conn_02x02_Top_Bottom; Molex_Mini-Fit_Jr_5566-04A_2x02_P4.20mm_Vertical
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J5, J9, J13: C96ABC; DIN41612_R_3x32_Male_Vertical_THT
J6, J7, J8, J10, J11, J12, J14, J15, J16: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
R1, R2: 120; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3: 220; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
+5V: J3.3, J3.4, J5.a1, J5.a32, J5.b1, J5.b32, J5.c1, J5.c32, J9.a1, J9.a32, J9.b1, J9.b32, J9.c1, J9.c32, J13.a1, J13.a32, J13.b1, J13.b32, J13.c1, J13.c32, R3.1
/CAN+: J5.a5, J9.a5, J13.a5, R1.2, R2.2
/CAN-: J1.2, J2.2, J5.a4, J9.a4, J13.a4
/GA1_0: J5.a6
/GA2: J4.6, J5.a8, J9.a8, J13.a8
/GA2_1: J9.a7
/GA3: J4.4, J5.a9, J9.a9, J13.a9
/GA3_0: J13.a6
/GA3_1: J13.a7
/GA4: J4.2, J5.a10, J9.a10, J13.a10
/USER1_3: J5.c3, J8.10
/USER1_4: J5.c4, J8.9
/USER1_5: J5.c5, J8.8
/USER1_6: J5.c6, J8.7
/USER1_7: J5.c7, J8.6
/USER1_8: J5.c8, J8.5
/USER1_9: J5.c9, J8.4
/USER1_10: J5.c10, J8.3
/USER1_11: J5.c11, J8.2
/USER1_13: J5.c13, J8.1
/USER1_14: J5.c14, J7.8
/USER1_15: J5.c15, J7.7
/USER1_16: J5.c16, J7.6
/USER1_17: J5.c17, J7.5
/USER1_18: J5.c18, J7.4
/USER1_19: J5.c19, J7.3
/USER1_20: J5.c20, J7.2
/USER1_21: J5.c21, J7.1
/USER1_23: J5.c23, J6.8
/USER1_24: J5.c24, J6.7
/USER1_25: J5.c25, J6.6
/USER1_26: J5.c26, J6.5
/USER1_27: J5.c27, J6.4
/USER1_28: J5.c28, J6.3
/USER1_29: J5.c29, J6.2
/USER1_30: J5.c30, J6.1
/USER2_3: J9.c3, J12.10
/USER2_4: J9.c4, J12.9
/USER2_5: J9.c5, J12.8
/USER2_6: J9.c6, J12.7
/USER2_7: J9.c7, J12.6
/USER2_8: J9.c8, J12.5
/USER2_9: J9.c9, J12.4
/USER2_10: J9.c10, J12.3
/USER2_11: J9.c11, J12.2
/USER2_13: J9.c13, J12.1
/USER2_14: J9.c14, J11.8
/USER2_15: J9.c15, J11.7
/USER2_16: J9.c16, J11.6
/USER2_17: J9.c17, J11.5
/USER2_18: J9.c18, J11.4
/USER2_19: J9.c19, J11.3
/USER2_20: J9.c20, J11.2
/USER2_21: J9.c21, J11.1
/USER2_23: J9.c23, J10.8
/USER2_24: J9.c24, J10.7
/USER2_25: J9.c25, J10.6
/USER2_26: J9.c26, J10.5
/USER2_27: J9.c27, J10.4
/USER2_28: J9.c28, J10.3
/USER2_29: J9.c29, J10.2
/USER2_30: J9.c30, J10.1
/USER3_3: J13.c3, J16.10
/USER3_4: J13.c4, J16.9
/USER3_5: J13.c5, J16.8
/USER3_6: J13.c6, J16.7
/USER3_7: J13.c7, J16.6
/USER3_8: J13.c8, J16.5
/USER3_9: J13.c9, J16.4
/USER3_10: J13.c10, J16.3
/USER3_11: J13.c11, J16.2
/USER3_13: J13.c13, J16.1
/USER3_14: J13.c14, J15.8
/USER3_15: J13.c15, J15.7
/USER3_16: J13.c16, J15.6
/USER3_17: J13.c17, J15.5
/USER3_18: J13.c18, J15.4
/USER3_19: J13.c19, J15.3
/USER3_20: J13.c20, J15.2
/USER3_21: J13.c21, J15.1
/USER3_23: J13.c23, J14.8
/USER3_24: J13.c24, J14.7
/USER3_25: J13.c25, J14.6
/USER3_26: J13.c26, J14.5
/USER3_27: J13.c27, J14.4
/USER3_28: J13.c28, J14.3
/USER3_29: J13.c29, J14.2
/USER3_30: J13.c30, J14.1
/~RESET~: J5.a14, J9.a14, J13.a14
GND: D1.1 (K), J3.1, J3.2, J4.1, J4.3, J4.5, J5.a2, J5.a7, J5.a12, J5.a22, J5.a31, J5.b2, J5.b12, J5.b22, J5.b31, J5.c2, J5.c12, J5.c22, J5.c31, J9.a2, J9.a6, J9.a12, J9.a22, J9.a31, J9.b2, J9.b12, J9.b22, J9.b31, J9.c2, J9.c12, J9.c22, J9.c31, J13.a2, J13.a12, J13.a22, J13.a31, J13.b2, J13.b12, J13.b22, J13.b31, J13.c2, J13.c12, J13.c22, J13.c31
unnamed: D1.2 (A), R3.2
unnamed: J1.1, R1.1
unnamed: J2.1, R2.1
