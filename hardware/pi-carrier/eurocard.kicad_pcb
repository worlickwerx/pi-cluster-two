File: hardware/pi-carrier/eurocard.kicad_pcb (KiCad board)
At the start: 2 copper layers, 159.9 x 99.9 mm, 76 parts, among them J1 molliebus, J2 Conn_01x03, J3 Conn_01x03, J4 Conn_02x20_Odd_Even, J5 Raspberry_Pi_2_3, J6 Conn_02x20_Odd_Even, J7 Conn_01x02, J8 Conn_02x08_Counter_Clockwise, J9 Conn_01x04, U1 SN74LVC1G07DBVR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

Commit message: pi-carrier: add bypass cap on INA169
Datasheet says optional, but better safe than sorry.
Parts:
- added C22: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, B.Cu at (150.6, 73.3)
Routing:
- net GND: track 135.0 -> 138.5 mm
- net +3V3: track 202.9 -> 205.6 mm

Commit message: pi-carrier: add PTC silk label
Other:
- board text added: "3A PTC"
